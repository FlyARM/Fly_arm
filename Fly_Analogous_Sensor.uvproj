# Keil uVision project Fly_Analogous_Sensor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: Fly_Analogous_Sensor +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Main
    ./Main/: main.c
  group Drivers
    ./Drivers/: SAM7.s
